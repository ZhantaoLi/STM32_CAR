# Keil uVision project test.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_MD
  c include: ..\SYSTEM\sys;..\SYSTEM\delay;..\SYSTEM\usart;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\HARDWARE;..\HARDWARE\inc;..\HARDWARE\MPU6050;..\HARDWARE\MPU6050\eMPL;..\APP;..\APP\inc;..\APP\timers
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: startup_stm32f10x_hd.s
  group APP
    ../APP/: app.h app.c
    ../APP/timers/: SOFtimers.c
    ../APP/src/: ledTASK.c uartTASK.c
  group USER
    ./: test.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay/: delay.c
  group HARDWARE
    ../HARDWARE/: Hardware.h Hardware.c
    ../SYSTEM/usart/: usart.c
    ../HARDWARE/src/: led.c adc.c timer.c stmflash.c I2C.c exti.c control.c
    ../HARDWARE/MPU6050/: mpu6050.c
    ../HARDWARE/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group FreeRTOS_CORE
    ../FreeRTOS/include/: FreeRTOSConfig.h
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group README
    ../: README.TXT
